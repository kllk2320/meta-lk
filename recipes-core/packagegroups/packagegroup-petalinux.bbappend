#Add more packages 
RDEPENDS_${PN} += "\
    lszrz \
    "
